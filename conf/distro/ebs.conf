## conf/distro/ebs.conf
```bitbake
require conf/distro/include/ebs.inc

#DISTRO = "torizon"
#DISTRO_NAME = "TorizonCore"

#DISTRO_FLAVOUR_experimental = " (EXPERIMENTAL)"
```
